FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
# the source code has update patch content, so no longger needed it
# SRC_URI:append = " \
#     file://0001-CMakeLists-Update-ROS_DISTRO-version-to-humble.patch \
#     "
